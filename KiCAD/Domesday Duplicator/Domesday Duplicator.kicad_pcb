# Repository vrunk11/DomesdayDuplicator

File README.md:

# Domesday Duplicator (DdD)

The Domesday Duplicator is a LaserDisc capture focused, USB 3.0 based DAQ capable of 40
million samples per second acquisition of analogue RF data at 10-bits resolution.

Please see the [Project Documentation](https://domesday86.github.io/DomesdayDuplicator/) for
details of the project and for access to the project documentation. For contributing
guidelines, see [CONTRIBUTING.md](CONTRIBUTING.md).

## The capture application

Capture is via an easy to use GUI capture application, with real-time signal analysis —
waveform, spectrum analyser and spectrogram, amplitude history and live capture statistics —
so you can see the RF while it is being sampled rather than after the fact.

The application also drives a Pioneer LaserDisc player over serial, runs whole-disc automatic
captures, and updates the Duplicator's own firmware and gateware over USB. The
[Capture Application documentation](https://domesday86.github.io/DomesdayDuplicator/capture-gui/)
covers every panel.

## Installing — no compilation required

**There is absolutely no need to compile anything.** All end-user installs must be performed
using the provided binary packages and firmware images. Building from source is a development
activity only, and nothing you need as a user requires it.

### The capture application

Download from the [releases page](https://github.com/Domesday86/DomesdayDuplicator/releases)
and follow the installation page for your platform:

| Platform | Package | Installation |
| --- | --- | --- |
| Linux | `DomesdayDuplicator-<version>.flatpak` | [Linux (Flatpak)](https://domesday86.github.io/DomesdayDuplicator/capture-gui/install-flatpak/) |
| macOS (Apple Silicon) | `DomesdayDuplicator-<version>-macos-arm64.dmg` | [macOS (DMG)](https://domesday86.github.io/DomesdayDuplicator/capture-gui/install-dmg/) |
| Windows 11 | `DomesdayDuplicator-<version>-windows-x64.msi` | [Windows (MSI)](https://domesday86.github.io/DomesdayDuplicator/capture-gui/install-msi/) |

Every release also carries `SHA256SUMS` and a `PROVENANCE.txt` recording the commit each
asset was built from. Verify your download against `SHA256SUMS`.

### Firmware and gateware

You do not build these either. Firmware releases publish a single signed update bundle,
`domesday-duplicator-update-<version>.dddfw`, and the capture application installs it for you:
**Tools → Firmware → Update firmware…**. The application verifies the bundle's signature and
every payload digest before it writes anything, and reports the version it reads back off the
live device afterwards. See
[Updating your Domesday Duplicator](https://domesday86.github.io/DomesdayDuplicator/capture-gui/updating-your-domesday-duplicator/).

A board that has never been programmed is handled the same way, with no jumper and no shell —
see [Bringing up a new or legacy board](https://domesday86.github.io/DomesdayDuplicator/capture-gui/bringing-up-a-board/).
Firmware releases also publish the raw images (`firmware.img`, the provisioning `.jic` and the
factory `.svf`) for bench recovery, but the bundle is the supported route.

Every released artefact is built by CI from the tagged commit; nothing is built on a
maintainer's machine or attached by hand
([release pipeline](https://domesday86.github.io/DomesdayDuplicator/development/release-pipeline/)).

## Cloning the repository

Everything is in this one repository. There are no git submodules, so a plain clone gives
you the complete project:

```
git clone https://github.com/Domesday86/DomesdayDuplicator.git
```

### Repository layout

| Directory | Contents |
| --- | --- |
| [hardware/](hardware/) | KiCad design for the custom DdD board, plus hardware documentation |
| [fpga/](fpga/) | Verilog gateware for the Terasic DE0-NANO (Cyclone IV) |
| [fx3/firmware/](fx3/firmware/) | Cypress FX3 USB 3.0 controller firmware |
| [fx3/programmer/](fx3/programmer/) | Host-side tool for programming the FX3 |
| [fx3/mkimage/](fx3/mkimage/) | `fx3-mkimage`, the project's own ELF-to-boot-image tool |
| [fx3/sdk/](fx3/sdk/) | Vendored Cypress FX3 SDK the firmware builds against |
| [ddd-gui/](ddd-gui/) | Qt 6 capture application, and the Flatpak/DMG/MSI packaging under `ddd-gui/packaging/` |
| [docs/](docs/) | Source of the project documentation website |
| [docs-vendor/](docs-vendor/) | Transcribed vendor service documentation for supported players |
| [nix/](nix/) | The single flake's shared helpers, default dev shell, NixOS module and whole-tree checks |
| [tools/](tools/) | Repository-wide scripts, run both by hand and by the checks |

## Developing the project

**Do NOT install from source unless you intend to develop the software** — see
[Installing](#installing--no-compilation-required) above for user installations.

### Nix on Linux is the only supported environment

**The only supported development and build environment is Nix on Linux.** There is exactly one
`flake.nix`, at the repository root, and exactly one `flake.lock`; every toolchain the project
needs is pinned by it, and CI builds through the same flake, so a build that fails under Nix
is a real failure rather than an environment quirk.

**Pull requests that introduce another development or build environment will not be accepted.**
That includes alternative build systems, per-distribution dependency lists, and packaging
intended to make a component build without Nix. If you develop on macOS or Windows, use a
Linux virtual machine — that is the supported route, and it is the only one.

### Building

Run any of these from anywhere in the working tree; Nix walks up to find the flake at the
root, so `.#ddd-gui` resolves identically from `ddd-gui/` and from the repository root.

| Component | Build | Development shell |
| --- | --- | --- |
| Capture application | `nix build .#ddd-gui` | `nix develop .#ddd-gui` |
| FX3 firmware | `nix build .#fx3-firmware` | `nix develop .#fx3` |
| FX3 programmer | `nix build .#fx3-programmer` | `nix develop .#fx3` |
| FX3 boot-image tool | `nix build .#fx3-mkimage` | `nix develop .#fx3` |
| FPGA gateware | `nix build .#bitstream` | `nix develop .#fpga` · `nix develop .#fpga-quartus` |
| Documentation site | `nix build .#docs-site` | `nix develop .#docs` |
| PCB | — | `nix develop .#hardware` |

```
nix develop                          # every component's tools in one shell
nix flake check                      # build everything and run the whole T1–T4 test suite
```

The capture application installs four binaries: `ddd-gui`, plus `ddd-update`, `ddd-jtag` and
`ddd-requantize`, which drive the same engine from a shell.

Components deliberately carry no flake of their own: an earlier layout gave each one a thin
flake for the `cd ddd-gui && nix develop` shorthand, and every one of those resolved
`nixos-unstable` into a lock file of its own — so entering the tree through a component quietly
got a different nixpkgs from the root pin. The reasoning is in the header comment of
[flake.nix](flake.nix).

Two caveats on the FPGA row. Quartus Prime Lite is unfree, `x86_64-linux` only and cannot be
served from a binary cache, so `nix build .#bitstream` means a multi-gigabyte first download
and is excluded from `nix flake check` — the per-commit tier must never require an unfree
download of anyone. It *is* built by CI, in a workflow of its own that runs on gateware
changes and from release tags, so every released bitstream is CI-built from the tagged commit.
`nix develop .#fpga` — without `-quartus` — gives the free tools instead: Verilog lint,
simulation and a language server, with no Quartus at all, and that covers most gateware work.

Build directories are `build/` under each component and are gitignored. Never build in-tree:
in the gateware's project directories in particular, Quartus rewrites the tracked `.qsf` on
every compile.

On NixOS, device permissions come from the flake's module — set
`hardware.domesdayDuplicator.enable = true;`, which covers the Duplicator, the FX3 and the
on-board USB-Blaster together. Elsewhere, see
[Linux device access](https://domesday86.github.io/DomesdayDuplicator/development/hardware-programming/linux-device-access/).

[AGENTS.md](AGENTS.md) records the project conventions and [TESTING.md](TESTING.md) the test
tiers, including the hardware-in-the-loop capture-integrity procedure that is the most
important test in the project.

## The Decode Family

The samples the DdD captures can be used with the whole family of decoders that make the FM RF
archival workflow ready to use today.

The original design was for the wide bandwidth of LaserDisc RF — making it suitable for all of
the more bandwidth restricted mediums too (that have a single stream of RF).

[Please see the documentation for more details](https://domesday86.github.io/DomesdayDuplicator/general/overview/)

## 3D Printed Case

The Domesday Duplicator also has [3D models](https://github.com/Domesday86/DomesdayDuplicator-Case)
and ready to use STL files for producing 3D printed cases, to protect from dust or line with
copper tape for affordable EMI shielding for example.

## Authors

Domesday Duplicator is designed and maintained by [Simon Inns](https://github.com/simoninns).

## Licences

- [Software Licence — GPLv3](LICENSE)
- [Hardware Licence — Creative Commons BY-SA 4.0](https://creativecommons.org/licenses/by-sa/4.0/)
  (full text in [hardware/pcb/LICENSE.txt](hardware/pcb/LICENSE.txt))

## KiCad design KiCAD/Domesday Duplicator/Domesday Duplicator.kicad_pcb

Parts:
J101: DE0-Nano_GPIO1; Socket_Strip_Straight_2x20_Pitch2.54mm
J102: DE0-Nano_GPIO0; Socket_Strip_Straight_2x20_Pitch2.54mm

Connections:
+5V: J101.11 (5V_VCC), J102.11 (5V_VCC); also elsewhere on the board
/RSEL_CTRL: J102.27 (GPIO_22); also elsewhere on the board
ADC_CLK: J102.40 (GPIO_33); also elsewhere on the board
ADC_DATA0: J102.39 (GPIO_32); also elsewhere on the board
ADC_DATA1: J102.38 (GPIO_31); also elsewhere on the board
ADC_DATA2: J102.37 (GPIO_30); also elsewhere on the board
ADC_DATA3: J102.36 (GPIO_29); also elsewhere on the board
ADC_DATA4: J102.35 (GPIO_28); also elsewhere on the board
ADC_DATA5: J102.34 (GPIO_27); also elsewhere on the board
ADC_DATA6: J102.33 (GPIO_26); also elsewhere on the board
ADC_DATA7: J102.32 (GPIO_25); also elsewhere on the board
ADC_DATA8: J102.31 (GPIO_24); also elsewhere on the board
ADC_DATA9: J102.28 (GPIO_23); also elsewhere on the board
GND: J101.12 (GND), J101.30 (GND), J102.12 (GND), J102.30 (GND); also elsewhere on the board
USB_CTL0: J101.34 (GPIO_27); also elsewhere on the board
USB_CTL1: J101.32 (GPIO_25); also elsewhere on the board
USB_CTL2: J101.28 (GPIO_23); also elsewhere on the board
USB_CTL3: J101.26 (GPIO_21); also elsewhere on the board
USB_CTL4: J101.24 (GPIO_19); also elsewhere on the board
USB_CTL5: J101.22 (GPIO_17); also elsewhere on the board
USB_CTL6: J101.20 (GPIO_15); also elsewhere on the board
USB_CTL7: J101.18 (GPIO_13); also elsewhere on the board
USB_CTL8: J101.16 (GPIO_11); also elsewhere on the board
USB_CTL9: J101.14 (GPIO_9); also elsewhere on the board
USB_CTL10: J101.10 (GPIO_7); also elsewhere on the board
USB_CTL11: J101.8 (GPIO_5); also elsewhere on the board
USB_CTL12: J101.6 (GPIO_3); also elsewhere on the board
USB_DATA0: J101.39 (GPIO_32); also elsewhere on the board
USB_DATA1: J101.37 (GPIO_30); also elsewhere on the board
USB_DATA2: J101.35 (GPIO_28); also elsewhere on the board
USB_DATA3: J101.33 (GPIO_26); also elsewhere on the board
USB_DATA4: J101.31 (GPIO_24); also elsewhere on the board
USB_DATA5: J101.27 (GPIO_22); also elsewhere on the board
USB_DATA6: J101.25 (GPIO_20); also elsewhere on the board
USB_DATA7: J101.23 (GPIO_18); also elsewhere on the board
USB_DATA8: J101.21 (GPIO_16); also elsewhere on the board
USB_DATA9: J101.19 (GPIO_14); also elsewhere on the board
USB_DATA10: J101.17 (GPIO_12); also elsewhere on the board
USB_DATA11: J101.15 (GPIO_10); also elsewhere on the board
USB_DATA12: J101.13 (GPIO_8); also elsewhere on the board
USB_DATA13: J101.9 (GPIO_6); also elsewhere on the board
USB_DATA14: J101.7 (GPIO_4); also elsewhere on the board
USB_DATA15: J101.5 (GPIO_2); also elsewhere on the board
USB_DATA16: J102.5 (GPIO_2); also elsewhere on the board
USB_DATA17: J102.6 (GPIO_3); also elsewhere on the board
USB_DATA18: J102.7 (GPIO_4); also elsewhere on the board
USB_DATA19: J102.8 (GPIO_5); also elsewhere on the board
USB_DATA20: J102.9 (GPIO_6); also elsewhere on the board
USB_DATA21: J102.10 (GPIO_7); also elsewhere on the board
USB_DATA22: J102.17 (GPIO_12); also elsewhere on the board
USB_DATA23: J102.18 (GPIO_13); also elsewhere on the board
USB_DATA24: J102.19 (GPIO_14); also elsewhere on the board
USB_DATA25: J102.20 (GPIO_15); also elsewhere on the board
USB_DATA26: J102.21 (GPIO_16); also elsewhere on the board
USB_DATA27: J102.22 (GPIO_17); also elsewhere on the board
USB_DATA28: J102.23 (GPIO_18); also elsewhere on the board
USB_DATA29: J102.24 (GPIO_19); also elsewhere on the board
USB_DATA30: J102.25 (GPIO_20); also elsewhere on the board
USB_DATA31: J102.26 (GPIO_21); also elsewhere on the board
USB_PCLK: J101.38 (GPIO_31); also elsewhere on the board

Notes on the sheet:
Note: All resistors 1% tolerance. All capacitors 10% tolerance. Unless otherwise noted

Parts:
J201: GPIFII_J7; Pin_Header_Straight_2x20_Pitch2.54mm
J202: GPIFII_J6; Pin_Header_Straight_2x20_Pitch2.54mm

Connections:
+5V: J202.3 (USB3_VBUS), J202.4 (USB3_VBUS); also elsewhere on the board
GND: J201.13 (GND), J201.15 (GND), J201.17 (GND), J201.25 (GND), J201.29 (GND), J201.39 (GND), J201.40 (GND), J202.6 (GND), J202.33 (GND), J202.37 (GND); also elsewhere on the board
USB_CTL0: J202.31 (CTL0); also elsewhere on the board
USB_CTL1: J202.29 (CTL1); also elsewhere on the board
USB_CTL2: J202.27 (CTL2); also elsewhere on the board
USB_CTL3: J202.25 (CTL3); also elsewhere on the board
USB_CTL4: J202.23 (CTL4_SW); also elsewhere on the board
USB_CTL5: J202.21 (CTL5); also elsewhere on the board
USB_CTL6: J202.19 (CTL6); also elsewhere on the board
USB_CTL7: J202.17 (CTL7); also elsewhere on the board
USB_CTL8: J202.15 (CTL8); also elsewhere on the board
USB_CTL9: J202.13 (CTL9); also elsewhere on the board
USB_CTL10: J202.11 (CTL10); also elsewhere on the board
USB_CTL11: J202.9 (CTL11); also elsewhere on the board
USB_CTL12: J202.7 (CTL12); also elsewhere on the board
USB_DATA0: J202.38 (DQ0); also elsewhere on the board
USB_DATA1: J202.36 (DQ1); also elsewhere on the board
USB_DATA2: J202.34 (DQ2); also elsewhere on the board
USB_DATA3: J202.32 (DQ3); also elsewhere on the board
USB_DATA4: J202.30 (DQ4); also elsewhere on the board
USB_DATA5: J202.28 (DQ5); also elsewhere on the board
USB_DATA6: J202.26 (DQ6); also elsewhere on the board
USB_DATA7: J202.24 (DQ7); also elsewhere on the board
USB_DATA8: J202.22 (DQ8); also elsewhere on the board
USB_DATA9: J202.20 (DQ9); also elsewhere on the board
USB_DATA10: J202.18 (DQ10); also elsewhere on the board
USB_DATA11: J202.16 (DQ11); also elsewhere on the board
USB_DATA12: J202.14 (DQ12); also elsewhere on the board
USB_DATA13: J202.12 (DQ13); also elsewhere on the board
USB_DATA14: J202.10 (DQ14); also elsewhere on the board
USB_DATA15: J202.8 (DQ15); also elsewhere on the board
USB_DATA16: J201.38 (DQ16); also elsewhere on the board
USB_DATA17: J201.36 (DQ17); also elsewhere on the board
USB_DATA18: J201.34 (DQ18); also elsewhere on the board
USB_DATA19: J201.32 (DQ19); also elsewhere on the board
USB_DATA20: J201.30 (DQ20); also elsewhere on the board
USB_DATA21: J201.28 (DQ21); also elsewhere on the board
USB_DATA22: J201.26 (DQ22); also elsewhere on the board
USB_DATA23: J201.24 (DQ23); also elsewhere on the board
USB_DATA24: J201.22 (DQ24); also elsewhere on the board
USB_DATA25: J201.20 (DQ25); also elsewhere on the board
USB_DATA26: J201.18 (DQ26); also elsewhere on the board
USB_DATA27: J201.16 (DQ27); also elsewhere on the board
USB_DATA28: J201.12 (DQ28); also elsewhere on the board
USB_DATA29: J201.10 (DQ29); also elsewhere on the board
USB_DATA30: J201.8 (DQ30); also elsewhere on the board
USB_DATA31: J201.6 (DQ31); also elsewhere on the board
USB_PCLK: J202.35 (PCLK); also elsewhere on the board

Notes on the sheet:
Key pin
Power is supplied from the VBUS of the USB3 connection, so we flag the supply point here

Parts:
C301, C303, C305, C307, C309, C311, C313, C314, C316, C317, C318: 100nF; C_0805
C302, C304, C306, C308, C310, C312, C315, C319: 2.2uF Tant; CP_Tantalum_Case-A_EIA-3216-18_Reflow
R301: 1K; R_0805
R302: 1K2; R_0805
U301: ADS828; SSOP-28_5.3x10.2mm_Pitch0.65mm
U302, U303: 74LVTH541_PWR; TSSOP-20_4.4x6.5mm_Pitch0.65mm

Connections:
+3.3VA: C316.1, C317.1, C318.1, C319.1, U301.28 (VDRV), U302.20 (VCC), U303.20 (VCC); also elsewhere on the board
+5VA: C313.1, C314.1, C315.1, U301.15 (+Vs), U301.27 (+Vs); also elsewhere on the board
/ADC/IN: U301.25 (IN); also elsewhere on the board
/ADC/REFB: C309.1, C310.1, R302.1, U301.19 (REFB); also elsewhere on the board
/ADC/REFT: C307.1, C308.1, R301.2, U301.22 (REFT); also elsewhere on the board
/RSEL_CTRL: U301.17 (RSEL); also elsewhere on the board
ADC_CLK: U301.14 (CLK); also elsewhere on the board
ADC_DATA0: U302.18 (Y0); also elsewhere on the board
ADC_DATA1: U302.17 (Y1); also elsewhere on the board
ADC_DATA2: U302.16 (Y2); also elsewhere on the board
ADC_DATA3: U302.15 (Y3); also elsewhere on the board
ADC_DATA4: U302.14 (Y4); also elsewhere on the board
ADC_DATA5: U302.13 (Y5); also elsewhere on the board
ADC_DATA6: U302.12 (Y6); also elsewhere on the board
ADC_DATA7: U302.11 (Y7); also elsewhere on the board
ADC_DATA8: U303.18 (Y0); also elsewhere on the board
ADC_DATA9: U303.17 (Y1); also elsewhere on the board
GND: C301.2, C302.2, C303.2, C304.2, C305.2, C306.2, C307.2, C308.2, C309.2, C310.2, C311.2, C312.2, C313.2, C314.2, C315.2, C316.2, C317.2, C318.2, C319.2, U301.1 (GND), U301.12 (~OE), U301.13 (PD), U301.16 (GND), U301.18 (~INT/EXT), U301.26 (GND), U302.1 (G1), U302.10 (GND), U302.19 (G2), U303.1 (G1), U303.4 (A2), U303.5 (A3), U303.6 (A4), U303.7 (A5), U303.8 (A6), U303.9 (A7), U303.10 (GND), U303.19 (G2); also elsewhere on the board
unnamed: U301.2 (Bit_1_(MSB)), U303.3 (A1)
unnamed: U301.3 (Bit_2), U303.2 (A0)
unnamed: U301.4 (Bit_3), U302.9 (A7)
unnamed: U301.5 (Bit_4), U302.8 (A6)
unnamed: U301.6 (Bit_5), U302.7 (A5)
unnamed: U301.7 (Bit_6), U302.6 (A4)
unnamed: U301.8 (Bit_7), U302.5 (A3)
unnamed: U301.9 (Bit_8), U302.4 (A2)
unnamed: U301.10 (Bit_9), U302.3 (A1)
unnamed: U301.11 (Bit_10_(LSB)), U302.2 (A0)
unnamed: C303.1, C304.1, U301.20 (ByB)
unnamed: C301.1, C302.1, U301.21 (ByT)
unnamed: C311.1, C312.1, U301.23 (CM)
unnamed: C305.1, C306.1, R301.1, R302.2, U301.24 (~IN)

Parts:
C401, C402, C408: 100nF; C_0805
C403: 130pF; C_0805
C404: 15pF; C_0805
C405: 200pF; C_0805
C406: 39pF; C_0805
C407: 110pF; C_0805
C409: 2.2uF Tant; CP_Tantalum_Case-A_EIA-3216-18_Reflow
J401: BNC_Rosenberger; BNC Socket
L401: 330nH; L_0805
L402: 270nH; L_0805
R401: 56R; R_0805
R402, R403, R407: 1K; R_0805
R404: 100R; R_0805
R405: 200R; R_0805
R406: 1K5; R_0805
R408: 680R; R_0805
R409: 560R; R_0805
R410, R411: 47R; R_0805
SW401: Gain Select; SW_DIP_x4_W7.62mm_Slide_Copal_CHS-B
U401: OPA690; SOIC-8_3.9x4.9mm_Pitch1.27mm

Connections:
+5VA: C408.1, C409.1, U401.7 (+Vs), U401.8 (~DIS); also elsewhere on the board
/ADC/IN: R411.2; also elsewhere on the board
/ADC/REFB: R403.1; also elsewhere on the board
/ADC/REFT: R402.2; also elsewhere on the board
GND: C402.2, C403.2, C405.2, C407.2, C408.2, C409.2, J401.2 (GND), J401.3 (GND), J401.4 (GND), J401.5 (GND), R401.1, U401.4 (-Vs); also elsewhere on the board
unnamed: C401.1, R402.1, R403.2, R404.1
unnamed: C402.1, R405.1
unnamed: C403.1, C404.1, L401.2, R410.2
unnamed: C404.2, C405.1, C406.1, L401.1, L402.2
unnamed: C406.2, C407.1, L402.1, R411.1
unnamed: C401.2, J401.1 (Signal), R401.2
unnamed: R406.2, SW401.1
unnamed: R407.2, SW401.2
unnamed: R408.2, SW401.3
unnamed: R409.2, SW401.4
unnamed: R404.2, U401.3 (IN+)
unnamed: R405.2, R406.1, R407.1, R408.1, R409.1, U401.2 (IN-)
unnamed: R410.1, SW401.5, SW401.6, SW401.7, SW401.8, U401.6 (Output)

Notes on the sheet:
50 Ohm impedance RF input
Note: The cable terminating resistor should take into account the parallel resistance of the dividing network: 1000 / 2 = 500 Ohms Rtotal = R1×R2/(R1+R2) (500 x 56) / (500 + 56) = 50.36 Ohms
2N Elliptic filter (14 MHz low-pass)
Filter capacitor tolerance 5%

Parts:
C501, C503: 10uF TANT; CP_Tantalum_Case-B_EIA-3528-21_Reflow
C502, C504: 100nF; C_0805
L501: 100uH; Inductor_Bourns-SRU8043
U501: LM1117-3.3; SOT-223-3_TabPin2

Connections:
+3.3VA: C503.1, C504.1, U501.2 (VO); also elsewhere on the board
+5V: L501.2; also elsewhere on the board
+5VA: C501.1, C502.1, L501.1, U501.3 (VI); also elsewhere on the board
GND: C501.2, C502.2, C503.2, C504.2, U501.1 (GND); also elsewhere on the board

Board: 2 copper layers, 95.2 x 57.2 mm, 59 parts (2 on the bottom side), 92 nets.

## Commit log (part)

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2023-05-16 Sequence mismatch capture option
    add an option in capture menu for enabling the program to stop the capture when a sequence mismatch is detected
    (the program now didn't stop unless its specified using the new option)
2023-05-16 Fix "Restore defaults" button
    Fix "Restore defaults" button so it also reset the "stop capture on sequence mismatch" when used
2023-11-27 Squashed commit of the following:
    commit 26032dc9a6c528fe9a96f419e9056aaa83d9626d
    Author: Adam Sampson <ats@offog.org>
    Date: Wed Jul 26 01:22:52 2023 +0100
    Avoid duplicate QVBoxLayout names.
    This is harmless, but Qt 6 warns about it.
    commit 7c03d6ca688d62603560613d1a122e73e86e12f7

Notices in the files:
KiCAD/Domesday Duplicator/Domesday Duplicator.kicad_pcb:
(c)2018 Simon Inns
License: Attribution-ShareAlike 4.0 International (CC BY-SA 4.0)
